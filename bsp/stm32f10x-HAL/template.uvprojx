# Keil uVision project template.uvprojx, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
